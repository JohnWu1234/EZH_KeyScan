# Keil uVision project keyscan_gpio_lpc541u68.uvprojx, settings and files
target keyscan_gpio_lpc541u68 debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: keyscan_gpio_lpc541u68.out
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x0)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC51U68JBD64
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: board;source;CMSIS;component/lists;component/serial_manager;component/uart;device;doc;drivers;src;startup;utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC51U68_flash.scf
  link misc: libs/keil_lib_power.lib
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h mpu_armv7.h mpu_armv8.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC51U68.h LPC51U68_features.h system_LPC51U68.c system_LPC51U68.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group source
    source/: gpio_led_output.c
  group startup
    startup/: startup_LPC51U68.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
target keyscan_gpio_lpc541u68 release (ARM-ADS)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.11.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: keyscan_gpio_lpc541u68.out
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x0)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC51U68JBD64
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC51U68_flash.scf
  link misc: libs/keil_lib_power.lib
--remove
